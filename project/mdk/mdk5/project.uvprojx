# Keil uVision project project.uvprojx, settings and files
target RT-Thread BSP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output @H.bin
  c flags: Optim=4 uC99=1
  c include: ..\..\..;..\..\..\Application;..\..\..\board;..\..\..\driver;..\..\..\..\rt-thread\include;..\..\..\..\rt-thread\libcpu\arm\cortex-m4;..\..\..\..\rt-thread\libcpu\arm\common;..\..\..\..\rt-thread\components\dfs\include;..\..\..\..\rt-thread\components\dfs\filesystems\devfs;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\rt-thread\components\finsh;..\..\..\..\rt-thread\components\libc\compilers\common;..\..\..\..\rt-thread\components\net\lwip-2.0.2\src;..\..\..\..\rt-thread\components\net\lwip-2.0.2\src\include;..\..\..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4;..\..\..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include;..\..\..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif;..\..\..\..\rt-thread\components\net\lwip-2.0.2\src\include\posix
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: ..\link.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Application
    ../../../Application/: main.cpp mnt.cpp
  group Board
    ../../../board/: board.c drv_clock.c drv_cputime.c
  group Drivers
    ../../../driver/: drv_gpio.c drv_emac.c
  group Kernel
    ../../../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../../rt-thread/components/drivers/misc/: pin.c
    ../../../../rt-thread/components/drivers/serial/: serial.c
    ../../../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    ../../../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
